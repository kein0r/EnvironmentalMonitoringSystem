# IAR project RFTemperaturHumiditySensor.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; DHT22; CC2530Generic; CC253x; IEEE_802.15.4
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: dht22_cfg.h IEEE_802.15.4_cfg.h main.c PlatformTypes.h
  group CC2530Generic
    CC2530Generic/: board.c board.h
  group CC253x
    CC253x/: CC253x.c CC253x.h
  group DHT22
    DHT22/: dht22.c dht22.h
  group IEEE_802.15.4
    IEEE_802.15.4/: IEEE_802.15.4.c IEEE_802.15.4.h
