<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2530Bee\CC2530Bee.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RFTemperaturHumiditySensor\RFTemperaturHumiditySensor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


