# IAR project CC2530Bee.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; CC2530Generic; CC253x; IEEE_802.15.4
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: CC2530Bee.h Config.h main.c
  group CC2530Generic
    CC2530Generic/: board.c board.h
  group CC253x
    CC253x/: CC253x.c CC253x.h PlatformTypes.h Timer2.c Timer2.h USART.c USART.h
  group IEEE_802.15.4
    IEEE_802.15.4/: IEEE_802.15.4.c IEEE_802.15.4.h
